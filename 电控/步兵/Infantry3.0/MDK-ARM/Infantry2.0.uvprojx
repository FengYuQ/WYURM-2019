# Keil uVision project Infantry2.0.uvprojx, settings and files
target Infantry2.0 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry2.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\IMCALib\Module\DMP;..\IMCALib\Task\algorithm;..\IMCALib\Task;..\IMCALib\Tool;..\IMCALib\Module\FreeRTOS\Source\CMSIS_RTOS;..\IMCALib\Module\FreeRTOS\Source\include;..\IMCALib\Module\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group DMP
    ../IMCALib/Module/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu9250.c
  group application
    ../IMCALib/Task/: can_task.c chassis_task.c control_task.c gimbal_task.c shoot_task.c
  group algorithm
    ../IMCALib/Task/algorithm/: pid.c ramp.c
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c freertos.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../IMCALib/Module/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group tool
    ../IMCALib/Tool/: imu_tool.c print_tool.c remote_tool.c
software components: CMSIS:CORE 4.3.0
